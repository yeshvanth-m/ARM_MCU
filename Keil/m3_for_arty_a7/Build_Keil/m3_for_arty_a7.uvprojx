# Keil uVision project m3_for_arty_a7.uvprojx, settings and files
target m3_for_arty_a7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM3/: system_ARTY_CM3.c
    ../cmsis/Device/Source/ARTY_CM3/ARM/: startup_ARTY_CM3.s
  group Main
    ../main/: main.c
target m3_for_arty_a7_sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 SIM_BUILD
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\main;..\platform;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry=Reset_Handler
target m3_for_arty_a7_v2c (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.0.2
